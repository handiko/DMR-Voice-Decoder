options:
  parameters:
    description: DMR Tier II/III RX, RTL-SDR, stock front end + 1 EPB burst decoder
    generate_options: qt_gui
    id: dmr_rx_hier
    output_language: python
    title: DMR RX (hier decoder) - RTL-SDR
  states: {}

blocks:
- name: audio_slot
  id: variable_qtgui_chooser
  parameters:
    comment: Which time slot to play. Encrypted calls are always muted.
    gui_hint: 3,1,1,1
    label: Play slot
    label0: Both slots
    label1: TS1
    label2: TS2
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: ch_cut
  id: variable
  parameters:
    comment: |-
      Channel LPF cutoff [Hz] (-6 dB). 5 kHz won the simulation;
      4.5 kHz is ~0.5 dB better once ppm is right
    value: '6000'
  states: {}
- name: ch_rate
  id: variable
  parameters:
    comment: 'Stage 2: 240 -> 48 kS/s'
    value: if_rate/5
  states: {}
- name: ch_tw
  id: variable
  parameters:
    comment: Channel LPF transition [Hz]
    value: '2500'
  states: {}
- name: decim1
  id: variable
  parameters:
    comment: 'Stage 1: 960 -> 240 kS/s'
    value: '4'
  states: {}
- name: dev_unit
  id: variable
  parameters:
    comment: 'DMR 4FSK: +-648 Hz / +-1944 Hz -> symbols +-1 / +-3'
    value: '648.0'
  states: {}
- name: dmr_freq
  id: variable
  parameters:
    comment: DMR carrier [Hz] (the one the P25 decoder flagged as DMR)
    value: dmr_freq_entry*1e6
  states: {}
- name: dmr_freq_entry
  id: variable_qtgui_entry
  parameters:
    label: DMR Freq(MHz)
    type: real
    value: '429.325'
  states: {}
- name: fine_hz
  id: variable_qtgui_range
  parameters:
    comment: |-
      Moves the channel inside the 240 kHz IF: OK for channels within +-30 kHz.
      Decoding re-locks on the first sync after a change.
    gui_hint: 0,2,1,1
    label: Fine tune [Hz]
    start: '-30000'
    step: '10'
    stop: '30000'
    value: '0'
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: samp_rate/decim1
  states: {}
- name: lo_offset
  id: variable
  parameters:
    comment: |-
      LO sits this far below the channel: keeps it off
      the RTL DC spike / LO leakage
    value: 100e3
  states: {}
- name: mbelib_path
  id: variable
  parameters:
    comment: |-
      AMBE+2 vocoder library for voice audio, loaded with ctypes.
      '' = search next to this .grc and on PATH for mbe-neo.dll (mbelib-neo 2.x,
      recommended: soft decision) or mbe.dll / libmbe (classic mbelib).
      Or give a full path, e.g. r'C:\\sdr\\mbelib-neo\\bin\\mbe-neo.dll'
    value: ''''''
  states: {}
- name: plan_ref_hz
  id: variable
  parameters:
    comment: |-
      Set to 0 to disable the configured plan
      (announced Chan_Freq always wins)
    value: 148.7215e6
  states: {}
- name: plan_ref_lpcn
  id: variable
  parameters:
    comment: |-
      Channel plan (optional): LPCN n = plan_ref_hz + (n - plan_ref_lpcn) * plan_step_hz.
      Inferred from two measured Tait control channels:
      LPCN 151 = 148.7215 MHz (site 15), LPCN 155 = 148.7713 MHz (site 16).
    value: '151'
  states: {}
- name: plan_step_hz
  id: variable
  parameters:
    comment: 'Measured: 4 LPCN steps = 49.8 kHz'
    value: '12500'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    comment: 'Your gqrx shows 9-10 ppm: same driver call, same value'
    gui_hint: 0,1,1,1
    label: Freq corr [ppm]
    start: '-60'
    step: '1'
    stop: '60'
    value: '35'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Back off if the waterfall shows images / a raised floor
    gui_hint: 0,0,1,1
    label: RF gain [dB]
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '29.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'RTL rate. 960 kS/s = 4800 x 200: integer chain 4 x 5 x 10 sps'
    value: 960e3
  states: {}
- name: sps
  id: variable
  parameters:
    comment: 10 samples per symbol (4800 Bd)
    value: int(round(ch_rate/4800))
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Audio gain after the vocoder (decoder output is ~+-1 full scale)
    gui_hint: 3,0,1,1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '8'
    value: '1.0'
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    comment: |-
      Default sound device. Occasional "aU"/"aO" on the console = sound card
      and RTL clocks differ slightly; harmless.
    device_name: ''''''
    samp_rate: '48000'
  states: {}
- name: chan_lpf
  id: low_pass_filter
  parameters:
    comment: 'Stage 2: channel filter, /5 -> 48 kS/s'
    cutoff_freq: ch_cut
    decim: '5'
    gain: '1'
    samp_rate: if_rate
    type: fir_filter_ccf
    width: ch_tw
    win: window.WIN_HAMMING
  states: {}
- name: dmr_decoder_0
  id: dmr_decoder
  parameters:
    audio_delay: '0.4'
    audio_slot: audio_slot
    color_code: '-1'
    comment: |-
      Hier block (open dmr_decoder_hier.grc to see inside):
      matched filter -> sync correlators -> burst framer EPB
      -> Layer 2 EPB -> AMBE+2 vocoder EPB
    dedup_s: '10.0'
    mbelib_path: mbelib_path
    plan_ref_hz: plan_ref_hz
    plan_ref_lpcn: plan_ref_lpcn
    plan_step_hz: plan_step_hz
    rf_hz: dmr_freq + fine_hz
    stats_every: '10.0'
    sync_thresh: '0.8'
  states: {}
- name: fft_if
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: if_rate
    fc: dmr_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,3
    legend: 'False'
    name: '"240 kHz around the channel (channel at 0)"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: hist_sym
  id: qtgui_histogram_sink_x
  parameters:
    bins: '120'
    comment: |-
      Peaks shifted sideways = carrier offset (fix ppm).
      Peaks smeared together = weak signal
    grid: 'True'
    gui_hint: 2,0,1,3
    legend: 'False'
    name: '"Symbol levels: want 4 sharp peaks at -3 -1 +1 +3"'
    size: '4800'
    type: float
    update_time: '0.20'
    xmax: '6'
    xmin: '-6'
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: 'FM discriminator: 600 Hz -> 1.0'
    gain: ch_rate/(2*3.141592653589793*dev_unit)
  states: {}
- name: rtlsdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    comment: RTL-SDR, manual gain, AGC off. "rtl=0,bias=1" for bias-T
    corr0: ppm
    freq0: dmr_freq - lo_offset
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: up48
  id: rational_resampler_xxx
  parameters:
    comment: 8 kHz -> 48 kHz (every sound card supports 48 kHz)
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: vol
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: xlate_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: lo_offset + fine_hz
    comment: 'Stage 1: channel to 0 Hz, wide LPF, /4 (~25 taps, only anti-alias)'
    decim: decim1
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 40e3, 120e3)
    type: ccf
  states: {}

connections:
- [chan_lpf, '0', quad_demod, '0']
- [dmr_decoder_0, '0', vol, '0']
- [dmr_decoder_0, '1', hist_sym, '0']
- [quad_demod, '0', dmr_decoder_0, '0']
- [rtlsdr_source_0, '0', xlate_0, '0']
- [up48, '0', audio_out, '0']
- [vol, '0', up48, '0']
- [xlate_0, '0', chan_lpf, '0']
- [xlate_0, '0', fft_if, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
